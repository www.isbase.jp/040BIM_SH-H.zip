Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [ContentGUID: 0bf2b43a-6102-4418-b428-4da8559a771d, VersionGUID: 997412aa-8e7a-48a2-af83-42e6da78f716, NumberOfSaves: 12], CoordinateReference [CoordinateBase: 共有座標], ExchangeRequirement [Structural]
File name: SH-Hシリーズ.ifc
Time: 2025-11-05T18:40:06+09:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.4.30.30 (JPN) - IFC 25.4.30.30

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: プロジェクト情報

# IfcBuilding
Pset_BuildingCommon - Reference: プロジェクト情報; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: プロジェクト情報; IsExternal: no
Pset_BuildingStoreyCommon - Reference: プロジェクト情報; sets with these values: 2

# IfcBuildingStorey: レベル:レベル 1, レベル 1
LongName: レベル 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: レベル 1

# IfcBuildingElementProxy: ISベース_SH:SH151H, ISベース_SH:SH151H:4553
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH151H; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: SH151H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.17792 m2; NetVolume: 0.00791001 m3

# IfcBuildingElementProxy: ISベース_SH:SH171H, ISベース_SH:SH171H:6915
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH171H
Pset_EnvironmentalImpactIndicators - Reference: SH171H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.24952 m2; NetVolume: 0.00866313 m3

# IfcBuildingElementProxy: ISベース_SH:SH172H, ISベース_SH:SH172H:6916
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH172H
Pset_EnvironmentalImpactIndicators - Reference: SH172H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.34823 m2; NetVolume: 0.010008 m3

# IfcBuildingElementProxy: ISベース_SH:SH201H, ISベース_SH:SH201H:6935
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH201H
Pset_EnvironmentalImpactIndicators - Reference: SH201H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.36292 m2; NetVolume: 0.00987531 m3

# IfcBuildingElementProxy: ISベース_SH:SH202H, ISベース_SH:SH202H:6936
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH202H
Pset_EnvironmentalImpactIndicators - Reference: SH202H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.46487 m2; NetVolume: 0.0113939 m3

# IfcBuildingElementProxy: ISベース_SH:SH203H, ISベース_SH:SH203H:9822
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH203H
Pset_EnvironmentalImpactIndicators - Reference: SH203H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.51197 m2; NetVolume: 0.0124399 m3

# IfcBuildingElementProxy: ISベース_SH:SH204H, ISベース_SH:SH204H:9830
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH204H
Pset_EnvironmentalImpactIndicators - Reference: SH204H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.93934 m2; NetVolume: 0.015664 m3

# IfcBuildingElementProxy: ISベース_SH:SH251H, ISベース_SH:SH251H:6944
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH251H
Pset_EnvironmentalImpactIndicators - Reference: SH251H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.56792 m2; NetVolume: 0.0121156 m3

# IfcBuildingElementProxy: ISベース_SH:SH252H, ISベース_SH:SH252H:6945
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH252H
Pset_EnvironmentalImpactIndicators - Reference: SH252H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.66887 m2; NetVolume: 0.0133117 m3

# IfcBuildingElementProxy: ISベース_SH:SH253H, ISベース_SH:SH253H:7153
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH253H
Pset_EnvironmentalImpactIndicators - Reference: SH253H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.77297 m2; NetVolume: 0.0151703 m3

# IfcBuildingElementProxy: ISベース_SH:SH254H, ISベース_SH:SH254H:7161
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH254H
Pset_EnvironmentalImpactIndicators - Reference: SH254H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.20638 m2; NetVolume: 0.0192472 m3

# IfcBuildingElementProxy: ISベース_SH:SH255H, ISベース_SH:SH255H:9846
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH255H
Pset_EnvironmentalImpactIndicators - Reference: SH255H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.27323 m2; NetVolume: 0.020846 m3

# IfcBuildingElementProxy: ISベース_SH:SH301H, ISベース_SH:SH301H:6957
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH301H
Pset_EnvironmentalImpactIndicators - Reference: SH301H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.92863 m2; NetVolume: 0.0161905 m3

# IfcBuildingElementProxy: ISベース_SH:SH302H, ISベース_SH:SH302H:6958
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH302H
Pset_EnvironmentalImpactIndicators - Reference: SH302H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.97009 m2; NetVolume: 0.0175615 m3

# IfcBuildingElementProxy: ISベース_SH:SH303H, ISベース_SH:SH303H:7178
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH303H
Pset_EnvironmentalImpactIndicators - Reference: SH303H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.41374 m2; NetVolume: 0.0219376 m3

# IfcBuildingElementProxy: ISベース_SH:SH304H, ISベース_SH:SH304H:7186
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH304H
Pset_EnvironmentalImpactIndicators - Reference: SH304H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.54475 m2; NetVolume: 0.0241047 m3

# IfcBuildingElementProxy: ISベース_SH:SH305H, ISベース_SH:SH305H:7194
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH305H
Pset_EnvironmentalImpactIndicators - Reference: SH305H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.82993 m2; NetVolume: 0.0310489 m3

# IfcBuildingElementProxy: ISベース_SH:SH351H, ISベース_SH:SH351H:6966
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH351H
Pset_EnvironmentalImpactIndicators - Reference: SH351H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.17823 m2; NetVolume: 0.0191783 m3

# IfcBuildingElementProxy: ISベース_SH:SH352H, ISベース_SH:SH352H:6967
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH352H
Pset_EnvironmentalImpactIndicators - Reference: SH352H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.73678 m2; NetVolume: 0.0263354 m3

# IfcBuildingElementProxy: ISベース_SH:SH353H, ISベース_SH:SH353H:7214
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH353H
Pset_EnvironmentalImpactIndicators - Reference: SH353H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.93115 m2; NetVolume: 0.0296736 m3

# IfcBuildingElementProxy: ISベース_SH:SH354H, ISベース_SH:SH354H:7215
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH354H
Pset_EnvironmentalImpactIndicators - Reference: SH354H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.06773 m2; NetVolume: 0.0331877 m3

# IfcBuildingElementProxy: ISベース_SH:SH355H, ISベース_SH:SH355H:7216
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH355H
Pset_EnvironmentalImpactIndicators - Reference: SH355H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.37587 m2; NetVolume: 0.0412404 m3

# IfcBuildingElementProxy: ISベース_SH:SH356H, ISベース_SH:SH356H:9859
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH356H
Pset_EnvironmentalImpactIndicators - Reference: SH356H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.41367 m2; NetVolume: 0.0471939 m3

# IfcBuildingElementProxy: ISベース_SH:SH401H, ISベース_SH:SH401H:6975
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH401H
Pset_EnvironmentalImpactIndicators - Reference: SH401H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.60141 m2; NetVolume: 0.0253697 m3

# IfcBuildingElementProxy: ISベース_SH:SH402H, ISベース_SH:SH402H:6976
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH402H
Pset_EnvironmentalImpactIndicators - Reference: SH402H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.02798 m2; NetVolume: 0.0303632 m3

# IfcBuildingElementProxy: ISベース_SH:SH403H, ISベース_SH:SH403H:7234
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH403H
Pset_EnvironmentalImpactIndicators - Reference: SH403H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.23115 m2; NetVolume: 0.0340714 m3

# IfcBuildingElementProxy: ISベース_SH:SH404H, ISベース_SH:SH404H:7235
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH404H
Pset_EnvironmentalImpactIndicators - Reference: SH404H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.43705 m2; NetVolume: 0.0383949 m3

# IfcBuildingElementProxy: ISベース_SH:SH405H, ISベース_SH:SH405H:7236
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH405H
Pset_EnvironmentalImpactIndicators - Reference: SH405H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.76319 m2; NetVolume: 0.0474026 m3

# IfcBuildingElementProxy: ISベース_SH:SH406H, ISベース_SH:SH406H:7248
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH406H
Pset_EnvironmentalImpactIndicators - Reference: SH406H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.70759 m2; NetVolume: 0.0741785 m3

# IfcBuildingElementProxy: ISベース_SH:SH451H, ISベース_SH:SH451H:6984
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH451H
Pset_EnvironmentalImpactIndicators - Reference: SH451H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.89981 m2; NetVolume: 0.0292915 m3

# IfcBuildingElementProxy: ISベース_SH:SH452H, ISベース_SH:SH452H:6985
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH452H
Pset_EnvironmentalImpactIndicators - Reference: SH452H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.33918 m2; NetVolume: 0.034721 m3

# IfcBuildingElementProxy: ISベース_SH:SH453H, ISベース_SH:SH453H:7268
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH453H
Pset_EnvironmentalImpactIndicators - Reference: SH453H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.55115 m2; NetVolume: 0.0388192 m3

# IfcBuildingElementProxy: ISベース_SH:SH454H, ISベース_SH:SH454H:7274
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH454H
Pset_EnvironmentalImpactIndicators - Reference: SH454H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.76605 m2; NetVolume: 0.0436152 m3

# IfcBuildingElementProxy: ISベース_SH:SH455H, ISベース_SH:SH455H:7282
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH455H
Pset_EnvironmentalImpactIndicators - Reference: SH455H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.11019 m2; NetVolume: 0.0536279 m3

# IfcBuildingElementProxy: ISベース_SH:SH456H, ISベース_SH:SH456H:7288
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH456H
Pset_EnvironmentalImpactIndicators - Reference: SH456H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.52784 m2; NetVolume: 0.0686595 m3

# IfcBuildingElementProxy: ISベース_SH:SH501H, ISベース_SH:SH501H:6993
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH501H
Pset_EnvironmentalImpactIndicators - Reference: SH501H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.89115 m2; NetVolume: 0.043917 m3

# IfcBuildingElementProxy: ISベース_SH:SH502H, ISベース_SH:SH502H:6994
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH502H
Pset_EnvironmentalImpactIndicators - Reference: SH502H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.11505 m2; NetVolume: 0.0492105 m3

# IfcBuildingElementProxy: ISベース_SH:SH503H, ISベース_SH:SH503H:7317
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH503H
Pset_EnvironmentalImpactIndicators - Reference: SH503H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.80627 m2; NetVolume: 0.0638369 m3

# IfcBuildingElementProxy: ISベース_SH:SH504H, ISベース_SH:SH504H:7318
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH504H
Pset_EnvironmentalImpactIndicators - Reference: SH504H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.45877 m2; NetVolume: 0.0821084 m3

# IfcBuildingElementProxy: ISベース_SH:SH505H, ISベース_SH:SH505H:7319
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH505H
Pset_EnvironmentalImpactIndicators - Reference: SH505H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.28777 m2; NetVolume: 0.111975 m3

# IfcBuildingElementProxy: ISベース_SH:SH506H, ISベース_SH:SH506H:7320
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH506H
Pset_EnvironmentalImpactIndicators - Reference: SH506H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.40822 m2; NetVolume: 0.121687 m3

# IfcBuildingElementProxy: ISベース_SH:SH551H, ISベース_SH:SH551H:7002
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH551H
Pset_EnvironmentalImpactIndicators - Reference: SH551H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.48405 m2; NetVolume: 0.0551808 m3

# IfcBuildingElementProxy: ISベース_SH:SH552H, ISベース_SH:SH552H:7003
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH552H
Pset_EnvironmentalImpactIndicators - Reference: SH552H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.84759 m2; NetVolume: 0.063909 m3

# IfcBuildingElementProxy: ISベース_SH:SH553H, ISベース_SH:SH553H:7358
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH553H
Pset_EnvironmentalImpactIndicators - Reference: SH553H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.5096 m2; NetVolume: 0.0797662 m3

# IfcBuildingElementProxy: ISベース_SH:SH554H, ISベース_SH:SH554H:7359
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH554H
Pset_EnvironmentalImpactIndicators - Reference: SH554H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.89097 m2; NetVolume: 0.0949769 m3

# IfcBuildingElementProxy: ISベース_SH:SH555H, ISベース_SH:SH555H:7360
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH555H
Pset_EnvironmentalImpactIndicators - Reference: SH555H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.75177 m2; NetVolume: 0.123043 m3

# IfcBuildingElementProxy: ISベース_SH:SH556H, ISベース_SH:SH556H:7361
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH556H
Pset_EnvironmentalImpactIndicators - Reference: SH556H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.5559 m2; NetVolume: 0.126142 m3

# IfcBuildingElementProxy: ISベース_SH:SH601H, ISベース_SH:SH601H:7011
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH601H
Pset_EnvironmentalImpactIndicators - Reference: SH601H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.87305 m2; NetVolume: 0.0615261 m3

# IfcBuildingElementProxy: ISベース_SH:SH602H, ISベース_SH:SH602H:7012
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH602H
Pset_EnvironmentalImpactIndicators - Reference: SH602H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.61627 m2; NetVolume: 0.0787525 m3

# IfcBuildingElementProxy: ISベース_SH:SH603H, ISベース_SH:SH603H:7386
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH603H
Pset_EnvironmentalImpactIndicators - Reference: SH603H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.02305 m2; NetVolume: 0.0941766 m3

# IfcBuildingElementProxy: ISベース_SH:SH604H, ISベース_SH:SH604H:7387
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH604H
Pset_EnvironmentalImpactIndicators - Reference: SH604H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.4339 m2; NetVolume: 0.105073 m3

# IfcBuildingElementProxy: ISベース_SH:SH605H, ISベース_SH:SH605H:7388
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH605H
Pset_EnvironmentalImpactIndicators - Reference: SH605H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 7.3267 m2; NetVolume: 0.140548 m3

# IfcBuildingElementProxy: ISベース_SH:SH606H, ISベース_SH:SH606H:7389
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH606H
Pset_EnvironmentalImpactIndicators - Reference: SH606H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 7.37635 m2; NetVolume: 0.151943 m3

# IfcBuildingElementProxy: ISベース_SH:SH651H, ISベース_SH:SH651H:7020
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH651H
Pset_EnvironmentalImpactIndicators - Reference: SH651H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.69819 m2; NetVolume: 0.0827791 m3

# IfcBuildingElementProxy: ISベース_SH:SH652H, ISベース_SH:SH652H:7021
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH652H
Pset_EnvironmentalImpactIndicators - Reference: SH652H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.2944 m2; NetVolume: 0.0951703 m3

# IfcBuildingElementProxy: ISベース_SH:SH653H, ISベース_SH:SH653H:7413
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH653H
Pset_EnvironmentalImpactIndicators - Reference: SH653H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.59417 m2; NetVolume: 0.105709 m3

# IfcBuildingElementProxy: ISベース_SH:SH654H, ISベース_SH:SH654H:7414
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH654H
Pset_EnvironmentalImpactIndicators - Reference: SH654H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.8999 m2; NetVolume: 0.115256 m3

# IfcBuildingElementProxy: ISベース_SH:SH655H, ISベース_SH:SH655H:7415
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH655H
Pset_EnvironmentalImpactIndicators - Reference: SH655H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 7.99542 m2; NetVolume: 0.156232 m3

# IfcBuildingElementProxy: ISベース_SH:SH656H, ISベース_SH:SH656H:7416
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH656H
Pset_EnvironmentalImpactIndicators - Reference: SH656H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 7.97915 m2; NetVolume: 0.16855 m3

# IfcBuildingElementProxy: ISベース_SH:SH701H, ISベース_SH:SH701H:7029
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH701H
Pset_EnvironmentalImpactIndicators - Reference: SH701H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.14519 m2; NetVolume: 0.0911294 m3

# IfcBuildingElementProxy: ISベース_SH:SH702H, ISベース_SH:SH702H:7030
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH702H
Pset_EnvironmentalImpactIndicators - Reference: SH702H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.50627 m2; NetVolume: 0.0953681 m3

# IfcBuildingElementProxy: ISベース_SH:SH703H, ISベース_SH:SH703H:7442
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH703H
Pset_EnvironmentalImpactIndicators - Reference: SH703H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.94905 m2; NetVolume: 0.113452 m3

# IfcBuildingElementProxy: ISベース_SH:SH704H, ISベース_SH:SH704H:7443
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH704H
Pset_EnvironmentalImpactIndicators - Reference: SH704H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 7.3859 m2; NetVolume: 0.125939 m3

# IfcBuildingElementProxy: ISベース_SH:SH705H, ISベース_SH:SH705H:9877
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH705H
Pset_EnvironmentalImpactIndicators - Reference: SH705H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 8.3567 m2; NetVolume: 0.166544 m3

# IfcBuildingElementProxy: ISベース_SH:SH706H, ISベース_SH:SH706H:18407
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH706H
Pset_EnvironmentalImpactIndicators - Reference: SH706H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 8.53796 m2; NetVolume: 0.17652 m3

# IfcBuildingElementProxy: ISベース_SH:SH751H, ISベース_SH:SH751H:7038
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH751H
Pset_EnvironmentalImpactIndicators - Reference: SH751H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.98127 m2; NetVolume: 0.104313 m3

# IfcBuildingElementProxy: ISベース_SH:SH752H, ISベース_SH:SH752H:7039
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH752H
Pset_EnvironmentalImpactIndicators - Reference: SH752H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 7.62849 m2; NetVolume: 0.126487 m3

# IfcBuildingElementProxy: ISベース_SH:SH753H, ISベース_SH:SH753H:7451
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH753H
Pset_EnvironmentalImpactIndicators - Reference: SH753H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 8.13915 m2; NetVolume: 0.141984 m3

# IfcBuildingElementProxy: ISベース_SH:SH754H, ISベース_SH:SH754H:7452
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH754H
Pset_EnvironmentalImpactIndicators - Reference: SH754H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 9.07342 m2; NetVolume: 0.183607 m3

# IfcBuildingElementProxy: ISベース_SH:SH755H, ISベース_SH:SH755H:9891
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH755H
Pset_EnvironmentalImpactIndicators - Reference: SH755H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 9.46156 m2; NetVolume: 0.215704 m3

# IfcBuildingElementProxy: ISベース_SH:SH801H, ISベース_SH:SH801H:7047
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH801H
Pset_EnvironmentalImpactIndicators - Reference: SH801H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 7.7464 m2; NetVolume: 0.124084 m3

# IfcBuildingElementProxy: ISベース_SH:SH802H, ISベース_SH:SH802H:7048
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH802H
Pset_EnvironmentalImpactIndicators - Reference: SH802H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 8.47822 m2; NetVolume: 0.149166 m3

# IfcBuildingElementProxy: ISベース_SH:SH803H, ISベース_SH:SH803H:7460
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH803H
Pset_EnvironmentalImpactIndicators - Reference: SH803H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 8.83356 m2; NetVolume: 0.163704 m3

# IfcBuildingElementProxy: ISベース_SH:SH804H, ISベース_SH:SH804H:7461
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH804H
Pset_EnvironmentalImpactIndicators - Reference: SH804H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 9.62935 m2; NetVolume: 0.198067 m3

# IfcBuildingElementProxy: ISベース_SH:SH805H, ISベース_SH:SH805H:9902
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SH805H
Pset_EnvironmentalImpactIndicators - Reference: SH805H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 10.0456 m2; NetVolume: 0.232512 m3
